# Keil uVision project 节点1.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC10L08XE STC-STC10
  cpu: IRAM(0-0xFF) XRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(45000000) MODP2
  output: 节点1 +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: STARTUP.A51 1101.c LCD12864A.c main.c server.c
